# Keil uVision project XiaoAi.uvproj, settings and files
target XiaoAiSystem (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: XiaoAi +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,HSE_VALUE=8000000
  c include: ..\Driver;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Huawei_LiteOS\kernel\include;..\Huawei_LiteOS\kernel\base\include;..\Huawei_LiteOS\platform\cpu\arm\cortex-m4;..\Huawei_LiteOS\platform\bsp\sample\config
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Stdlib
    ./: startup_stm32f10x_hd.s
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c misc.c
  group startup
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ../User/: main.c stm32f10x_it.c common.c
  group Driver
    ../Driver/: driver.c usart.c delay.c
